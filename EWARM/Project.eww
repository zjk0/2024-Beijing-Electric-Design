<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LCD_ili9488.ewp</path>
  </project>
  <batchBuild />
</workspace>
